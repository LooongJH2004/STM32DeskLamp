# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Start;.\Library;.\Model;.\Project\User;.\Project\ExternLibrary;.\Project\Hardware;.\Project\System;.\Project\Hardware\InternalFlash;.\Project\Hardware\Key;.\Project\Hardware\LED;.\Project\Hardware\OLED;.\Project\Hardware\TIMER;.\Project\Hardware\USART;.\Project\Hardware\USART_DMA;.\Project\Hardware\Encoder;.\Project\Hardware\I2C_Driver;.\Project\Hardware\Sensor;.\Project\Hardware\DHT11;.\Project\Hardware\LDR;.\Project\App\Lighting;.\Project\App\SystemModel;.\Project\App\UI;.\Project\App\Gesture;.\Project\App\SensorHub;.\Project\App\Protocol;.\Project\App\Control;.\Project\ExternLibrary
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group User
    ./Project/User/: Config.h main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Hardware
    ./Project/Hardware/TIMER/: Timer.c Timer.h
    ./Project/Hardware/OLED/: OLED.c OLED.h OLED_Font.h
    ./Project/Hardware/LED/: LED.c LED.h
    ./Project/Hardware/Key/: Key.c Key.h KeyManager.c KeyManager.h
    ./Project/Hardware/Encoder/: Encoder.h Encoder.c
    ./Project/Hardware/I2C_Driver/: I2C_Driver.h I2C_Driver.c
    ./Project/Hardware/Sensor/: PAJ7620.c PAJ7620.h
    ./Project/Hardware/DHT11/: DHT11.c DHT11.h
    ./Project/Hardware/LDR/: LDR.h LDR.c
    ./Project/Hardware/USART_DMA/: USART_DMA.h USART_DMA.c
  group System
    ./Project/System/: SystemSupport.h SystemSupport.c
  group ExternLibrary
    ./Project/ExternLibrary/: cJSON.c cJSON.h
  group App
    ./Project/App/Lighting/: LightCtrl.c LightCtrl.h KeyEventForLightCtrl.c
    ./Project/App/SystemModel/: SystemModel.c SystemModel.h
    ./Project/App/SensorHub/: SensorHub.c SensorHub.h
    ./Project/App/UI/: UIManager.c UIManager.h
    ./Project/App/Protocol/: Protocol.h Protocol.c Protocol_CRC.c Protocol_CRC.h
    ./Project/App/Control/: ControlManager.h ControlManager.c
